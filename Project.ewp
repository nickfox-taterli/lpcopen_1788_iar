# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: applications\CMSIS\CMSIS\Include; applications\lpc_core\lpc_chip\usbd_rom; applications\lpc_core\lpc_chip\chip_common; applications\lpc_core\lpc_chip\chip_17xx_40xx; applications\lpc_core\lpc_board; applications\lpc_core\lpc_board\board_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib/borad
    applications/lpc_core/lpc_board/: board.c board_sysinit.c
    applications/lpc_core/lpc_board/board_common/: mem_tests.c
  group lib/borad/hal
    applications/lpc_core/lpc_board/board_hal/: k9f1g08u0d.c sst39vf3201b.c
  group lib/chip_17xx_40xx
    applications/lpc_core/lpc_chip/chip_17xx_40xx/: adc_17xx_40xx.c can_17xx_40xx.c chip_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c pwm_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c wwdt_17xx_40xx.c
  group lib/common
    applications/lpc_core/lpc_chip/chip_common/: fpu_init.c iap.c ring_buffer.c
  group main
    applications/startup_code/: iar_startup_lpc177x_8x.s sysinit.c
    applications/: main.c
